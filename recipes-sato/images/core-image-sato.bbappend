IMAGE_INSTALL += "helloworld-mf"
IMAGE_INSTALL += "helloworld-at"
IMAGE_INSTALL += "helloworld-cm"
